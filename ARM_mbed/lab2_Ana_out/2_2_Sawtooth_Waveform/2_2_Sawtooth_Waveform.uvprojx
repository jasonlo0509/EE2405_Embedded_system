# Keil uVision project 2_2_Sawtooth_Waveform.uvprojx, settings and files
target 2_2_Sawtooth_Waveform (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.pdsc
  output: 2_2_Sawtooth_Waveform
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DFEATURE_IPV4=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DTARGET_K64F -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1487782436.56 -DMBEDTLS_ENTROPY_HARDWARE_ALT -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed/.; mbed/TARGET_K64F; mbed/TARGET_K64F/TARGET_Freescale; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api; mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED,-DMBEDTLS_ENTROPY_HARDWARE_ALT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group 
    ./: mbed_config.h main.cpp
  group TARGET_MCU_K64F
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/: peripheral_clock_defines.h
  group drivers
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
  group api
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: PeripheralPins.h PortNames.h gpio_object.h objects.h
  group TARGET_K64F
    mbed/TARGET_K64F/: MK64F12.h MK64F12_features.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h fsl_device_registers.h system_MK64F12.h
  group TARGET_FRDM
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: PeripheralNames.h PinNames.h crc.h device.h fsl_clock_config.h fsl_phy.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed_board.o mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o mbed.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h Callback.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Driver_Common.h Driver_Storage.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PlatformMutex.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h SingletonPtr.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
